Commit message: done

File: envs/robots/jaco6DOF.urdf (robot description, URDF)
Before this commit: robot j2n6s300, 15 links, 14 joints
Links:
- removed link base
Joints:
- removed joint j2n6s300_joint_base
